# IAR project Exercise8.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\..\Inc; ..\..\GUIConfig; ..\..\bsp\include; ..\..\bsp\third_party; ..\..\bsp\third_party\STM32CubeF7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\bsp\third_party\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\Software\uC-CPU; ..\..\Software\uC-CPU\ARM-Cortex-M4\IAR; ..\..\Software\uC-LIB; ..\..\Software\uCOS-III; ..\..\Software\uCOS-III\Source; ..\..\Software\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\..\Software\uC-GUI\Start\GUI\Core; ..\..\Software\uC-GUI\Start\GUI\DisplayDriver; ..\..\Software\uC-GUI\Start\GUI\Widget; ..\..\Software\uC-GUI\Start\GUI\WM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\bsp\cfg\iar\STM32F746xx_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: gui-library.a
  group APP
    ../: adc.c adc.h alarm.c alarm.h app_cfg.h app_main.c cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h protected_led.c protected_led.h pushbutton.c pushbutton.h scuba.c scuba.h
    ../../Inc/: GUIDEMO_API.h project.h
  group APP/GUIConfig
    ../../GUIConfig/: GUI_X_uCOS-III.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group APP/GUIDemo
    ../../GUIDemo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_API.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c MicriumLogo.c
  group BSP
    ../../bsp/: README_ISR_HANDLER.txt
  group BSP/cfg/iar
    ../../bsp/cfg/iar/: stm32f746xx_flash.icf
  group BSP/include
    ../../bsp/include/: bsp.h bsp_clock.h bsp_led.h bsp_os.h bsp_osal.h bsp_pb.h bsp_test.h bsp_touch.h project.h stm32f7xx_hal_conf.h
  group BSP/source
    ../../bsp/source/: bsp.c bsp_clock.c bsp_led.c bsp_os.c bsp_osal.c bsp_pb.c bsp_test.c bsp_touch.c cpu_bsp.c
  group BSP/source/startup
    ../../bsp/source/startup/: system_stm32f7xx.c
  group BSP/source/startup/iar
    ../../bsp/source/startup/iar/: startup_stm32f746xx.s
  group BSP/third_party
    ../../bsp/third_party/: stm32746g_discovery_sdram.c stm32746g_discovery_sdram.h
  group BSP/third_party/STM32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Include
    ../../bsp/third_party/stm32cubef7/Drivers/CMSIS/Device/ST/STM32F7xx/Include/: stm32f746xx.h stm32f7xx.h system_stm32f7xx.h
  group BSP/third_party/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc
    ../../bsp/third_party/stm32cubef7/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_conf_template.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sdram.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.h stm32f7xx_ll_usb.h
  group BSP/third_party/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy
    ../../bsp/third_party/stm32cubef7/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group BSP/third_party/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src
    ../../bsp/third_party/stm32cubef7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group MicriumSoftware/uC/CPU
    ../../Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group MicriumSoftware/uC/CPU/ARM-Cortex-M4/IAR
    ../../Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group MicriumSoftware/uC/GUI/Start/Core
    ../../Software/uC-GUI/Start/GUI/Core/: Global.h GUI.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h IP_FS.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h SEGGER.h
  group MicriumSoftware/uC/GUI/Start/DisplayDriver
    ../../Software/uC-GUI/Start/GUI/DisplayDriver/: GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Private.h
  group MicriumSoftware/uC/GUI/Start/Widget
    ../../Software/uC-GUI/Start/GUI/Widget/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GRAPH.h GRAPH_Private.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_HOOK.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h KNOB.h KNOB_Private.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h
  group MicriumSoftware/uC/GUI/Start/WM
    ../../Software/uC-GUI/Start/GUI/WM/: WM.h WM_GUI.h WM_Intern.h
  group MicriumSoftware/uC/LIB
    ../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group MicriumSoftware/uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group MicriumSoftware/uC/OS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR
    ../../Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group MicriumSoftware/uC/OS-III/Source
    ../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
